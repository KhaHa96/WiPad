# IAR project WiPad.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52832_xxAA NordicSemi nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NRF52832_XXAA; BOARD_PCA10040; NRF_SD_BLE_API_VERSION=7; S132; SOFTDEVICE_PRESENT
  ICCARM.CCDiagSuppress: Pe111, Go029
  ICCARM.CCIncludePath2: Toolchain; ..\Kernel\FreeRTOS\source\include; ..\Kernel\FreeRTOS\portable\IAR\nrf52; ..\Kernel\FreeRTOS\portable\CMSIS\nrf52; ..\Configuration; ..\Board_Support\MCU; ..\Board_Support\MCU\hal; ..\Board_Support\MCU\legacy; ..\Board_Support\MCU\clock; ..\Board_Support\MCU\power; ..\Board_Support\MCU\spi; ..\Board_Support\MCU\gpio; ..\Board_Support\MCU\boards; ..\Board_Support\Drivers; ..\Middleware\Libraries\util; ..\Middleware\Libraries\log; ..\Middleware\Libraries\experimental_section_vars; ..\Middleware\Libraries\strerror; ..\Middleware\Libraries\log\src; ..\Middleware\Libraries\memobj; ..\Middleware\Libraries\balloc; ..\Middleware\Libraries\fprintf; ..\Middleware\Libraries\ringbuf; ..\Middleware\Libraries\atomic; ..\Middleware\Libraries\queue; ..\Middleware\Libraries\timer; ..\Middleware\Libraries\atomic_flags; ..\Middleware\Libraries\mutex; ..\Middleware\Libraries\fds; ..\Middleware\Libraries\atomic_fifo; ..\Middleware\Libraries\fstorage; ..\Middleware\Libraries\bsp; ..\Middleware\Libraries\button; ..\Middleware\RF_Stack\BLE_Stack; ..\Middleware\RF_Stack\BLE_Stack\ble_advertising; ..\Middleware\RF_Stack\BLE_Stack\ble_db_discovery; ..\Middleware\RF_Stack\BLE_Stack\ble_link_ctx_manager; ..\Middleware\RF_Stack\BLE_Stack\nrf_ble_gq; ..\Middleware\RF_Stack\BLE_Stack\nrf_ble_qwr; ..\Middleware\RF_Stack\BLE_Stack\nrf_ble_gatt; ..\Middleware\RF_Stack\BLE_Stack\peer_manager; ..\Middleware\RF_Stack\BLE_Stack\ble_services\ble_adm; ..\Middleware\RF_Stack\BLE_Stack\ble_services\ble_att; ..\Middleware\RF_Stack\BLE_Stack\ble_services\ble_reg; ..\Middleware\RF_Stack\BLE_Stack\ble_services\ble_cts_c; ..\Middleware\RF_Stack\Softdevice; ..\Middleware\Services; ..\Middleware\Services\BLE_Service; ..\Middleware\Services\NVM_Service; ..\Application; ..\Application\Attribution; ..\Application\Registration; ..\Application\Display; ..\Utilities\Math; ..\Utilities\Strings; ..\Utilities\Time
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WiPad.hex
  ILINK.IlinkOutputFile: WiPad.out
  ILINK.IlinkIcfFile: WiPad.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NRF52832_XXAA; BOARD_PCA10040; NRF_SD_BLE_API_VERSION=7; S132; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: Toolchain; ..\Kernel\FreeRTOS\source\include; ..\Kernel\FreeRTOS\portable\IAR\nrf52; ..\Kernel\FreeRTOS\portable\CMSIS\nrf52; ..\Configuration; ..\Board_Support\MCU; ..\Board_Support\MCU\hal; ..\Board_Support\MCU\legacy; ..\Board_Support\MCU\clock; ..\Board_Support\MCU\power; ..\Board_Support\MCU\spi; ..\Board_Support\MCU\gpio; ..\Board_Support\MCU\boards; ..\Board_Support\Drivers; ..\Middleware\Libraries\util; ..\Middleware\Libraries\log; ..\Middleware\Libraries\experimental_section_vars; ..\Middleware\Libraries\strerror; ..\Middleware\Libraries\log\src; ..\Middleware\Libraries\memobj; ..\Middleware\Libraries\balloc; ..\Middleware\Libraries\fprintf; ..\Middleware\Libraries\ringbuf; ..\Middleware\Libraries\atomic; ..\Middleware\Libraries\queue; ..\Middleware\Libraries\timer; ..\Middleware\Libraries\atomic_flags; ..\Middleware\Libraries\mutex; ..\Middleware\Libraries\fds; ..\Middleware\Libraries\atomic_fifo; ..\Middleware\Libraries\fstorage; ..\Middleware\Libraries\bsp; ..\Middleware\Libraries\button; ..\Middleware\RF_Stack\BLE_Stack; ..\Middleware\RF_Stack\BLE_Stack\ble_advertising; ..\Middleware\RF_Stack\BLE_Stack\ble_db_discovery; ..\Middleware\RF_Stack\BLE_Stack\ble_link_ctx_manager; ..\Middleware\RF_Stack\BLE_Stack\nrf_ble_gq; ..\Middleware\RF_Stack\BLE_Stack\nrf_ble_qwr; ..\Middleware\RF_Stack\BLE_Stack\nrf_ble_gatt; ..\Middleware\RF_Stack\BLE_Stack\peer_manager; ..\Middleware\RF_Stack\BLE_Stack\ble_services\ble_adm; ..\Middleware\RF_Stack\BLE_Stack\ble_services\ble_att; ..\Middleware\RF_Stack\BLE_Stack\ble_services\ble_reg; ..\Middleware\RF_Stack\BLE_Stack\ble_services\ble_cts_c; ..\Middleware\RF_Stack\Softdevice; ..\Middleware\Services; ..\Middleware\Services\BLE_Service; ..\Application; ..\Application\Attribution; ..\Application\Registration; ..\Application\Display; ..\Utilities\Math
  ICCARM.CCOptStrategy: 0
  group Application
    ../Application/: AppMgr.c
  group Application/Attribution
    ../Application/Attribution/: Attribution.c
  group Application/Display
    ../Application/Display/: Display.c
  group Application/Registration
    ../Application/Registration/: Registration.c
  group Board_Support/Drivers/Low_Level_Abstraction/Spi
    ../Board_Support/Drivers/Low_Level_Abstraction/Spi/: Spi_al.c
  group Board_Support/MCU/boards
    ../Board_Support/MCU/boards/: boards.c
  group Board_Support/MCU/clock
    ../Board_Support/MCU/clock/: nrf_drv_clock.c nrfx_clock.c
  group Board_Support/MCU/gpio
    ../Board_Support/MCU/gpio/: nrfx_gpiote.c
  group Kernel/FreeRTOS
    ../Kernel/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Kernel/FreeRTOS/source/portable/MemMang/: heap_1.c
    ../Kernel/FreeRTOS/portable/IAR/nrf52/: port.c
    ../Kernel/FreeRTOS/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group Middleware/Libraries/atomic
    ../Middleware/Libraries/atomic/: nrf_atomic.c
  group Middleware/Libraries/atomic_fifo
    ../Middleware/Libraries/atomic_fifo/: nrf_atfifo.c
  group Middleware/Libraries/atomic_flags
    ../Middleware/Libraries/atomic_flags/: nrf_atflags.c
  group Middleware/Libraries/balloc
    ../Middleware/Libraries/balloc/: nrf_balloc.c
  group Middleware/Libraries/bsp
    ../Middleware/Libraries/bsp/: bsp.c bsp_btn_ble.c
  group Middleware/Libraries/button
    ../Middleware/Libraries/button/: app_button.c
  group Middleware/Libraries/experimental_section_vars
    ../Middleware/Libraries/experimental_section_vars/: nrf_section_iter.c
  group Middleware/Libraries/fds
    ../Middleware/Libraries/fds/: fds.c
  group Middleware/Libraries/fstorage
    ../Middleware/Libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
  group Middleware/Libraries/log
    ../Middleware/Libraries/log/src/: nrf_log_frontend.c
  group Middleware/Libraries/memobj
    ../Middleware/Libraries/memobj/: nrf_memobj.c
  group Middleware/Libraries/queue
    ../Middleware/Libraries/queue/: nrf_queue.c
  group Middleware/Libraries/strerror
    ../Middleware/Libraries/strerror/: nrf_strerror.c
  group Middleware/Libraries/timer
    ../Middleware/Libraries/timer/: app_timer_freertos.c
  group Middleware/Libraries/util
    ../Middleware/Libraries/util/: app_error.c app_error_weak.c app_util_platform.c
  group Middleware/RF_Stack/BLE_Stack
    ../Middleware/RF_Stack/BLE_Stack/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
  group Middleware/RF_Stack/BLE_Stack/ble_advertising
    ../Middleware/RF_Stack/BLE_Stack/ble_advertising/: ble_advertising.c
  group Middleware/RF_Stack/BLE_Stack/ble_db_discovery
    ../Middleware/RF_Stack/BLE_Stack/ble_db_discovery/: ble_db_discovery.c
  group Middleware/RF_Stack/BLE_Stack/ble_link_ctx_manager
    ../Middleware/RF_Stack/BLE_Stack/ble_link_ctx_manager/: ble_link_ctx_manager.c
  group Middleware/RF_Stack/BLE_Stack/ble_services/ble_adm
    ../Middleware/RF_Stack/BLE_Stack/ble_services/ble_adm/: ble_adm.c
  group Middleware/RF_Stack/BLE_Stack/ble_services/ble_att
    ../Middleware/RF_Stack/BLE_Stack/ble_services/ble_att/: ble_att.c
  group Middleware/RF_Stack/BLE_Stack/ble_services/ble_cts_c
    ../Middleware/RF_Stack/BLE_Stack/ble_services/ble_cts_c/: ble_cts_c.c
  group Middleware/RF_Stack/BLE_Stack/ble_services/ble_reg
    ../Middleware/RF_Stack/BLE_Stack/ble_services/ble_reg/: ble_reg.c
  group Middleware/RF_Stack/BLE_Stack/nrf_ble_gatt
    ../Middleware/RF_Stack/BLE_Stack/nrf_ble_gatt/: nrf_ble_gatt.c
  group Middleware/RF_Stack/BLE_Stack/nrf_ble_gq
    ../Middleware/RF_Stack/BLE_Stack/nrf_ble_gq/: nrf_ble_gq.c
  group Middleware/RF_Stack/BLE_Stack/nrf_ble_qwr
    ../Middleware/RF_Stack/BLE_Stack/nrf_ble_qwr/: nrf_ble_qwr.c
  group Middleware/RF_Stack/BLE_Stack/peer_manager
    ../Middleware/RF_Stack/BLE_Stack/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
  group Middleware/RF_Stack/Softdevice
    ../Middleware/RF_Stack/Softdevice/: nrf_sdh.c nrf_sdh_ble.c
  group Middleware/Services/BLE_Service
    ../Middleware/Services/BLE_Service/: BLE_Service.c
  group Middleware/Services/NVM_Service
    ../Middleware/Services/NVM_Service/: NVM_Service.c
  group Startup
    ../Startup/: iar_startup_nrf52.s main.c system_nrf52.c
  group Utilities/Math
    ../Utilities/Math/: Maths.c
  group Utilities/Strings
    ../Utilities/Strings/: Strings.c
  group Utilities/Time
    ../Utilities/Time/: Time.c
